## boards/shields/Triaxial6K/Kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config SHIELD_TRIAXIAL6K
    def_bool $(shields_list_contains,Triaxial6K)
```
